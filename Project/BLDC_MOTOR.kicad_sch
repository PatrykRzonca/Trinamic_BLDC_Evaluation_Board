File: Project/BLDC_MOTOR.kicad_sch (KiCad schematic)
At the start: 27 parts, among them Q201 2N7002, U201 TMC6200-TA-T

Commit message: More files cleanup
Other:
- company: Quasi Peak -> ${COMPANY}
