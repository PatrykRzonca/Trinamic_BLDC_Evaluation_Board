File: Project/eval_board_tmc6200-ta.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: More files cleanup
Other:
- company: Quasi Peak -> ${COMPANY}
